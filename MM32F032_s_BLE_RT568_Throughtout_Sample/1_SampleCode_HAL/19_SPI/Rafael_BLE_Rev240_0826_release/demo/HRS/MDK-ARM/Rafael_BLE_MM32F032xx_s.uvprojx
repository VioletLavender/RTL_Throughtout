# Keil uVision project Rafael_BLE_MM32F032xx_s.uvprojx, settings and files
target Rafael_BLE_MM32F032xx_s (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32F032R8T6 MindMotion
  pack: MindMotion.MM32F032_DFP.1.0.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Rafael_BLE_MM32F032xx_s +hex
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  AfterMake: fromelf --text -c "$L@L.axf" --output "$L@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\..\..\3_Device\CMSIS\KEIL_CORE;..\..\..\..\..\..\3_Device\MM32F032xx_s\HAL_lib\inc;..\..\..\..\..\..\3_Device\MM32F032xx_s\Include;..\..\..\..\..\..\3_Device\MM32F032xx_s\Source\KEIL_StartAsm;..\Peripheral\inc;..\..\..\include\rf_include;..\..\..\include\;..\..\..\porting\rf_porting;..\..\..\porting\;..\;..\inc;..\..\..\include\rf_include;..\..\..\include;..\..\..\..\..\..\3_Device\MM32F032xx_s\Include;..\..\..\..\..\..\3_Device\MM32F032xx_s\HAL_lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../../../../../../3_Device/MM32F032xx_s/Source/: system_MM32F032xx_s.c
    ../../../../../../3_Device/MM32F032xx_s/Source/KEIL_StartAsm/: startup_MM32F032xx_s_KEIL.s
  group APP
    ../: main.c user.c BleAppSetting.h
  group Peripheral
    ../Peripheral/: spi.c systick.c uart.c
  group PORTING
    ../../../porting/: mcu_definition.h porting_misc.c porting_spi.c
    ../../../porting/rf_porting/: porting_LLtimer.c
  group HAL_LIB
    ../../../../../../3_Device/MM32F032xx_s/HAL_lib/src/: HAL_adc.c HAL_bkp.c HAL_crc.c HAL_dbg.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_tim.c HAL_uart.c HAL_uid.c HAL_ver.c HAL_wwdg.c
  group RF_SOURCE
    ../../../source/: profile_tab.c profile_tab_client.c Rafael_BLE_MM32F032xx_s.lib
